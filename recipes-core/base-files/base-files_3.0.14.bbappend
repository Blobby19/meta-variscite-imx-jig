FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_prepend = "file://fstab "
